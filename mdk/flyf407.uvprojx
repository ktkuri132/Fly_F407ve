# Keil uVision project flyf407.uvprojx, settings and files
target fly_debug (6240000::V6.24::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: flyf407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F40_41xxx
  c include: ..\bsp;..\app;C:\General_template_Project\BSP\CMSIS\Core\Include;C:\General_template_Project\BSP\CMSIS\Core\Include\m-profile;C:\General_template_Project\BSP\stm32f4\CORE;C:\General_template_Project\Control;C:\General_template_Project\Device;C:\General_template_Project\Driver_Framework;C:\General_template_Project\Middleware
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c control.c init.c
  group devive
    C:/General_template_Project/Device/mpu6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    C:/General_template_Project/Device/hmc588/: hmc588.c
  group driver
    ../bsp/: i2c_bus.c delay.c adc.c i2c_dev.c irq.c led.c misc.c nvic.c usart.c
  group drivrt_framework
    C:/General_template_Project/Driver_Framework/: dev_frame.c
    C:/General_template_Project/Driver_Framework/i2c/: df_iic.c
    C:/General_template_Project/Driver_Framework/key/: df_key.c
  group control
    C:/General_template_Project/Control/: filter.c pid.c
  group bsp
    C:/General_template_Project/BSP/stm32f4/CORE/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group middleware
    C:/General_template_Project/Middleware/shell/: shell.c
    C:/General_template_Project/Middleware/trans/: stde.c terminal_link.c
